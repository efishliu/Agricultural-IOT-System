<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SampleApp.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build All</name>
      <member>
        <project>SampleApp</project>
        <configuration>ESP - Coordinator</configuration>
      </member>
      <member>
        <project>SampleApp</project>
        <configuration>In Premise Display - End Device</configuration>
      </member>
      <member>
        <project>SampleApp</project>
        <configuration>Load Control Device - Router</configuration>
      </member>
      <member>
        <project>SampleApp</project>
        <configuration>PCT - End Device</configuration>
      </member>
      <member>
        <project>SampleApp</project>
        <configuration>Range Extender - Router</configuration>
      </member>
      <member>
        <project>SampleApp</project>
        <configuration>Simple Metering - End Device</configuration>
      </member>
      <member>
        <project>SampleApp</project>
        <configuration>Simple Metering - Router</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


